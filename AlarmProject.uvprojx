# Keil uVision project AlarmProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AlarmProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\System\sys;.\Function;.\System\delay;.\System\usart;.\Function
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ./System/sys/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h system_stm32f10x.c
  group User
    ./User/: main.c startup_stm32f10x_hd.s
  group Function
    ./Function/: clock.c clock.h beep.c beep.h uartContact.c uartContact.h setNVIC.c setNVIC.h
